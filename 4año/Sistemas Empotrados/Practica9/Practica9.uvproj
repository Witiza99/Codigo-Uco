# Keil uVision project Practica9.uvproj, settings and files
target Simulator (ARM-ADS)
  device: LPC2378 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Blinky
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group Codigo de inicio
    ./: LPC2300.s
  group Llamadas a sistema
    ./: Retarget.c Serial.c
  group Codigo fuente
    ./: HAL.c Practica_SO_GPIO_1.c
  group Sistema Operativo
    ./: Instand-UP.c
