# Keil uVision project Practica2.uvproj, settings and files
target Practica2 (ARM-ADS)
  device: LPC2387 NXP
  cpu: IRAM(0x40000000-0x4000FFFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Practica2
  c flags: Optim=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x10000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group Codigo de inicio
    ./: LPC2300.s
  group Llamadas a sistema
    E:/ARM/Boards/Keil/MCB2300/Blinky/: Serial.c Retarget.c
  group Codigo Fuente
    ./: timers.c HAL.c
