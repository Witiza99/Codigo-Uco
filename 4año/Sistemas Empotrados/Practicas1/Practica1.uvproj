# Keil uVision project Practica1.uvproj, settings and files
target Practica1 (ARM-ADS)
  device: LPC2378 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Practica1
  c flags: Optim=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group Codigo de inicio
    ./: LPC2300.s
  group Lamadas a sistema
    E:/ARM/Boards/Keil/MCB2300/Blinky/: Retarget.c Serial.c
  group Codigo Fuente
    ./: Practica1.c
  group Documentacion
    ./: Resumen.txt
